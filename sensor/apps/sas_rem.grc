<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sas_rem</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1.000e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hop_time</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_channels</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>sas_ed_threshold</key>
<param><key>id</key><value>sas_ed_threshold_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
<param><key>threshold</key><value>200</value></param>
</block>
<block>
<key>sas_psql_insert</key>
<param><key>id</key><value>sas_psql_insert_0</value></param>
<param><key>N</key><value>fft_len</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
</block>
<block>
<key>sas_sas_buffer</key>
<param><key>id</key><value>sas_sas_buffer_0</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>sas_send_data</key>
<param><key>id</key><value>sas_send_data_0</value></param>
<param><key>N</key><value>fft_len</value></param>
<param><key>num_split</key><value>num_channels</value></param>
<param><key>port</key><value>6000</value></param>
<param><key>host</key><value>192.168.1.21</value></param>
</block>
<block>
<key>sas_uhd_control</key>
<param><key>id</key><value>sas_uhd_control_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hop_time</key><value>hop_time</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>max_bw</key><value>150e6</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>B:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>utils_nmea_reader</key>
<param><key>id</key><value>utils_nmea_reader_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>protocol</key><value>'gpsd'</value></param>
<param><key>port</key><value>8354</value></param>
</block>
<block>
<key>utils_psd_cvf</key>
<param><key>id</key><value>utils_psd_cvf_0</value></param>
<param><key>alpha</key><value>0.8</value></param>
<param><key>fft_len</key><value> fft_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>window_type</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>decision</source_key><sink_key>occ</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>noise_floor</source_key><sink_key>noise_floor</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>ip</source_key><sink_key>ip</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>mac</source_key><sink_key>mac</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>nodeid</source_key><sink_key>nodeid</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>samp_rate</source_key><sink_key>samp_rate</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>samp_rate</source_key><sink_key>bw</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>bandwidth</source_key><sink_key>samp_rate</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>bandwidth</source_key><sink_key>bw</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>control</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>gps_msg</source_key><sink_key>latlong</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>gps_msg</source_key><sink_key>gps</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_psd_cvf_0</source_block_id><sink_block_id>sas_ed_threshold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
