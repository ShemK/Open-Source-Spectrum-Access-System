<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sas_rem</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>364</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sas_ed_threshold</key>
<param><key>id</key><value>sas_ed_threshold_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>threshold</key><value>30</value></param>
</block>
<block>
<key>sas_psql_insert</key>
<param><key>id</key><value>sas_psql_insert_0</value></param>
<param><key>N</key><value>fft_len</value></param>
<param><key>num_channels</key><value>1</value></param>
</block>
<block>
<key>sas_sas_buffer</key>
<param><key>id</key><value>sas_sas_buffer_0</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>utils_nmea_reader</key>
<param><key>id</key><value>utils_nmea_reader_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>protocol</key><value>'nmea'</value></param>
<param><key>port</key><value>2222</value></param>
</block>
<block>
<key>utils_psd_cvf</key>
<param><key>id</key><value>utils_psd_cvf_0</value></param>
<param><key>alpha</key><value>0.8</value></param>
<param><key>fft_len</key><value> fft_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>window_type</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>decision</source_key><sink_key>decision</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>number_of_samps</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>gps_msg</source_key><sink_key>latlong</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_psd_cvf_0</source_block_id><sink_block_id>sas_ed_threshold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
