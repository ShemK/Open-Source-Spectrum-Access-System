<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sas_rem</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1.000e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hop_time</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_channels</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>8e-5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2e6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1e-2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>sas_ed_threshold</key>
<param><key>id</key><value>sas_ed_threshold_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
<param><key>threshold</key><value>200</value></param>
</block>
<block>
<key>sas_psql_insert</key>
<param><key>id</key><value>sas_psql_insert_0</value></param>
<param><key>N</key><value>fft_len</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
</block>
<block>
<key>sas_sas_buffer</key>
<param><key>id</key><value>sas_sas_buffer_0</value></param>
<param><key>N</key><value>N</value></param>
</block>
<block>
<key>sas_send_data</key>
<param><key>id</key><value>sas_send_data_0</value></param>
<param><key>N</key><value>fft_len</value></param>
<param><key>num_split</key><value>num_channels</value></param>
<param><key>port</key><value>6000</value></param>
<param><key>host</key><value>192.168.1.21</value></param>
</block>
<block>
<key>sas_uhd_control</key>
<param><key>id</key><value>sas_uhd_control_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hop_time</key><value>hop_time</value></param>
<param><key>gain</key><value>20</value></param>
</block>
<block>
<key>signal_exciter_random_gate</key>
<param><key>id</key><value>signal_exciter_random_gate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_off_dur</key><value>1.5</value></param>
<param><key>max_on_dur</key><value>2</value></param>
<param><key>min_off_dur</key><value>0.2</value></param>
<param><key>min_on_dur</key><value>0.5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>seed</key><value>2017</value></param>
</block>
<block>
<key>signal_exciter_random_signal</key>
<param><key>id</key><value>signal_exciter_random_signal_0</value></param>
<param><key>act_car</key><value>13</value></param>
<param><key>add_sync</key><value>False</value></param>
<param><key>backoff</key><value>10.97</value></param>
<param><key>base_word</key><value>False</value></param>
<param><key>cp_len</key><value>3</value></param>
<param><key>ptype</key><value>cpm.LREC</value></param>
<param><key>cpw</key><value>5</value></param>
<param><key>components</key><value>5</value></param>
<param><key>mus</key><value>[200,450,1500,2500,3500]</value></param>
<param><key>sigmas</key><value>[50,75,750,250,250]</value></param>
<param><key>weights</key><value>[.29,.60,.08,.01,.02]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>64</value></param>
<param><key>fso</key><value>0.</value></param>
<param><key>interp_len</key><value>1</value></param>
<param><key>interp_taps</key><value>[1]</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>max_freq</key><value>4e3</value></param>
<param><key>mod_idx</key><value>0.75</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>beta</key><value>0.35</value></param>
<param><key>pilot_count</key><value>4</value></param>
<param><key>pilot_loc</key><value>[0, 4, 8, 12]</value></param>
<param><key>ppf</key><value>False</value></param>
<param><key>pulse_len</key><value>1</value></param>
<param><key>pulse_shape</key><value>[1]</value></param>
<param><key>samp_overlap</key><value>0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>seed</key><value>-1</value></param>
<param><key>mod</key><value>signal_exciter.QAM</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>order</key><value>2</value></param>
<param><key>mtype</key><value>signal_exciter.OFDM</value></param>
<param><key>spf</key><value>1</value></param>
<param><key>ntaps</key><value>256</value></param>
<param><key>taper</key><value>[]</value></param>
<param><key>wpm</key><value>20</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>B:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>utils_nmea_reader</key>
<param><key>id</key><value>utils_nmea_reader_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>protocol</key><value>'nmea'</value></param>
<param><key>port</key><value>2222</value></param>
</block>
<block>
<key>utils_psd_cvf</key>
<param><key>id</key><value>utils_psd_cvf_0</value></param>
<param><key>alpha</key><value>0.8</value></param>
<param><key>fft_len</key><value> fft_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>window_type</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>decision</source_key><sink_key>occ</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>noise_floor</source_key><sink_key>noise_floor</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_ed_threshold_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>ip</source_key><sink_key>ip</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>mac</source_key><sink_key>mac</sink_key></connection>
<connection><source_block_id>sas_psql_insert_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>nodeid</source_key><sink_key>nodeid</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>samp_rate</source_key><sink_key>samp_rate</sink_key></connection>
<connection><source_block_id>sas_sas_buffer_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>samp_rate</source_key><sink_key>bw</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>bandwidth</source_key><sink_key>samp_rate</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>bandwidth</source_key><sink_key>bw</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>sas_send_data_0</sink_block_id><source_key>center_freq</source_key><sink_key>center_freq</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>control</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>sas_uhd_control_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_exciter_random_gate_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_exciter_random_signal_0</source_block_id><sink_block_id>signal_exciter_random_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>utils_psd_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>sas_psql_insert_0</sink_block_id><source_key>gps_msg</source_key><sink_key>latlong</sink_key></connection>
<connection><source_block_id>utils_nmea_reader_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>utils_psd_cvf_0</source_block_id><sink_block_id>sas_ed_threshold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
